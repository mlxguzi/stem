# Keil uVision project PWM.uvproj, settings and files
target Target 1 (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: PWM +hex
  c flags: Optimize=7 SizeSpeed=1
  c define: FOSC_160000
  c include: ..\..\Include
  group Source
    ./Code/: PWM.c
  group Common
    ../../Common/: Delay.c Common.c
  group Startup
    ../../Startup/: STARTUP.A51
