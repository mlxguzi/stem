# Keil uVision project I2C_Slave.uvproj, settings and files
target I2C_Slave (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: I2C_Slave +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  c include: ..\..\..\Include
  group Source
    ./Code/: I2C_S.c
  group Common
    ../../../Common/: Common.c Delay.c led1.c
  group Startup
    ../../../Startup/: STARTUP.A51
